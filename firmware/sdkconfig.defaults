## firmware/sdkconfig.defaults
```kconfig
CONFIG_ESP_CONSOLE_UART_BAUDRATE=460800

CONFIG_ESP_TIMER_SUPPORTS_ISR_DISPATCH_METHOD=y
```
